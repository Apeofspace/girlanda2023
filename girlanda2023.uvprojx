# Keil uVision project girlanda2023.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.2.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: girlanda2023
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --datacompressor=off
  group Source Group 1
    ./: main.c main.h inits.c irqs.c time.c led_funcs.c
software components: Device:Startup 2.0.0, Drivers:PORT 2.0.0, Drivers:RST_CLK 2.0.0, Drivers:SSP 2.0.0, Drivers:TIMER 2.0.0
